# Keil uVision project FlashNVol_LPC23xx.uvproj, settings and files
target LPC23xx (ARM-ADS)
  device: LPC2388 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: FlashNVol_LPC23xx +hex
  c flags: Optim=1
  c define: LPC2XXX
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Source Group 1
    ./: flash_nvol.c target_LPC23xx.c Startup_LPC23xx.s main_lpc23xx.c
