# Keil uVision project FlashNVol_LPC11xx.uvproj, settings and files
target LPC11xx (ARM-ADS)
  device: LPC11C14x301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: FlashNVol_LPC11xx +hex
  c flags: Optim=1
  c define: LPC11XX
  c include: ./Core_CM0
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: flash_nvol.c main_lpc11xx.c
  group Core_CM0
    ./Core_CM0/: system_LPC11xx.c core_cm0.c
    ./: startup_LPC11xx.s
