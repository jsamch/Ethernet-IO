# Keil uVision project FlashNVol_LPC17xx.uvproj, settings and files
target LPC17xx (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: FlashNVol_LPC17xx +hex
  c flags: Optim=1 wLevel=2
  c define: LPC17XX
  c include: .\Core_CM3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  link misc: --info unused
  group Source Group 1
    ./: flash_nvol.c main_lpc17xx.c
  group Core_CM3
    ./Core_CM3/: system_LPC17xx.c core_cm3.c type.h
    ./: startup_LPC17xx.s
