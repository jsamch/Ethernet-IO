# Keil uVision project FlashNVol_LPC13xx.uvproj, settings and files
target LPC13xx (ARM-ADS)
  device: LPC1343 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: FlashNVol_LPC13xx +hex
  c flags: Optim=1
  c define: LPC13XX
  c include: ./Core_CM3
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: main_lpc13xx.c flash_nvol.c
  group Core_CM3
    ./Core_CM3/: core_cm3.c system_LPC13xx.c type.h
    ./: startup_LPC13xx.s
